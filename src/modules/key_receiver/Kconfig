## src/modules/key_receiver/Kconfig
```kconfig
menuconfig MODULES_KEY_RECEIVER
 bool "key_receiver"
 default n
 ---help---
 	Enable support for key_receiver
```
